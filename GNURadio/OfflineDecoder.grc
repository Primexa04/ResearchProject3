options:
  parameters:
    author: Manolis Surligas (surligas@gmail.com)
    description: Generic FSK/MSK decoder supporting AX.25 framing schemes
    generate_options: no_gui
    generator_class_name: PythonNoGuiGenerator
    generator_module: gnuradio.grc.workflows.python_nogui
    id: satnogs_fsk_ax25
    output_language: python
    title: satnogs_fsk_ax25
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '8'
  states: {}
- name: variable_ax25_decoder_0
  id: variable_ax25_decoder
  parameters:
    addr: HS0AK
    crc_check: 'True'
    descrambling: 'True'
    error_correction: 'True'
    frame_len: '1024'
    ssid: '11'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1.0'
  states: {}
- name: antenna
  id: parameter
  parameters:
    type: str
    value: '""'
  states: {}
- name: baudrate
  id: parameter
  parameters:
    type: eng_float
    value: '9600'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: 1024//2
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/ol21495/Music/clockRecoveryMM.raw
    type: float
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/ol21495/Music/symSyncIn.raw
    type: float
  states: {state: disabled}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: /home/ol21495/Music/KNACKSAT2_2026-03-03T02_34_00cf32.raw
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_2_0
  id: blocks_file_sink
  parameters:
    file: /home/ol21495/Music/KNACKSAT2_2026-03-03T02_34_00Dopplercf32.raw
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/ol21495/Music/KNACKSAT2_2026-02-27T05_17_00Doppler_FIRcf32.raw
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1024'
    max_iter: '4096'
    scale: 1.0/1024.0
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: 76800*100
    type: complex
  states: {state: disabled}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1.0'
    samp_rate: baudrate*decimation
    sensitivity: '-baudrate*decimation'
  states: {}
- name: bw
  id: parameter
  parameters:
    comment: |-
      The bandwidth should configure RF filters on some devices.
      Set to 0.0 for automatic calculation.
    label: Bandwidth
    type: eng_float
    value: '0.0'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: ff
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: 0.5/8.0
    gain_omega: 2 * math.pi / 100
    mu: '0.5'
    omega: '2'
    omega_relative_limit: '0.01'
    type: float
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.001'
    max_dev: '0.01'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '4'
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: ff
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '202500'
    decim: '16'
    samp_rate: '1228800'
    taps: firdes.low_pass(1,1228800, 50000,10000)
    type: ccc
  states: {state: disabled}
- name: gain
  id: parameter
  parameters:
    comment: |-
      Generic gain value. 
      Each Soapy module
      will try to linearize this
      value by properly setting
      the device specific gains.
    type: eng_float
    value: '0.0'
  states: {}
- name: gain_mode
  id: parameter
  parameters:
    comment: |-
      Set the gain mode of the Soapy.
      Can be "Overall", "Specific"
      or "Settings Field"
    type: str
    value: '"Overall"'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '400430000'
    gain1: '''manual'''
    manual_gain1: '50'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '1228800'
    type: fc32
    uri: ip:192.168.1.60
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import Hamlib
  states: {state: disabled}
- name: lo_offset
  id: parameter
  parameters:
    comment: |-
      To avoid the SDR carrier at the DC
      we shift the LO a little further
    type: eng_float
    value: 200e3
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 0.625* baudrate
    decim: decimation // 2
    gain: '1'
    samp_rate: baudrate*decimation
    type: fir_filter_ccf
    width: baudrate / 8.0
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    comment: |-
      Perform a relaxed filter to increase 
      the performance of the auto frequency
      correction
    cutoff_freq: baudrate*1.25
    decim: '1'
    gain: '1'
    samp_rate: baudrate*decimation
    type: fir_filter_ccf
    width: baudrate / 2.0
    win: window.WIN_HAMMING
  states: {}
- name: ppm
  id: parameter
  parameters:
    comment: |-
      The frequency correction in PPM
      to correct for a local oscillator frequency deviation
    type: eng_float
    value: '0'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '78125'
    interp: '76800'
    type: ccc
  states: {}
- name: rx_freq
  id: parameter
  parameters:
    type: eng_float
    value: '600632500'
  states: {}
- name: samp_rate_rx
  id: parameter
  parameters:
    label: Device Sampling rate
    type: eng_float
    value: '0.0'
  states: {}
- name: satellites_check_address_0
  id: satellites_check_address
  parameters:
    address: HS0K
    direction: '"from"'
  states: {}
- name: satellites_doppler_correction_0
  id: satellites_doppler_correction
  parameters:
    file: /home/ol21495/Music/dopplerKNACKSAT2_2026-03-03T02_30_00.txt
    samp_rate: 1228800/16
    t0: '1772505250'
    timesync_tag: '""'
  states: {state: disabled}
- name: satellites_kiss_server_sink_0
  id: satellites_kiss_server_sink
  parameters:
    address: '"0.0.0.0"'
    port: '8102'
  states: {}
- name: satnogs_frame_decoder_0_0
  id: satnogs_frame_decoder
  parameters:
    decoder_object: variable_ax25_decoder_0
    itype: byte
    vlen: '1'
  states: {}
- name: satnogs_waterfall_sink_0
  id: satnogs_waterfall_sink
  parameters:
    center_freq: '0.0'
    fft_size: '1024'
    filename: /home/ol21495/Music/freqCorrected.dat
    mode: '1'
    rps: '10'
    samp_rate: baudrate*decimation
  states: {}
- name: satnogs_waterfall_sink_1
  id: satnogs_waterfall_sink
  parameters:
    center_freq: '0.0'
    fft_size: '1024'
    filename: /home/ol21495/Music/KNACKSAT2_2026-03-03T02_34_00waterfall.dat
    mode: '1'
    rps: '10'
    samp_rate: 1228800/16
  states: {state: disabled}
- name: satnogs_waterfall_sink_1_0
  id: satnogs_waterfall_sink
  parameters:
    center_freq: '0.0'
    fft_size: '1024'
    filename: /home/ol21495/Music/KNACKSAT2_2026-03-03T02_34_00waterfallDoppler.dat
    mode: '1'
    rps: '10'
    samp_rate: 1228800/16
  states: {state: disabled}

connections:
- [analog_quadrature_demod_cf_0_0, '0', dc_blocker_xx_0, '0']
- [analog_quadrature_demod_cf_0_0_0_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_file_source_0, '0', satellites_doppler_correction_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_vco_c_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', satnogs_waterfall_sink_0, '0']
- [blocks_throttle2_0, '0', satellites_doppler_correction_0, '0']
- [blocks_vco_c_0, '0', blocks_multiply_xx_0, '1']
- [dc_blocker_xx_0, '0', blocks_file_sink_1, '0']
- [dc_blocker_xx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [dc_blocker_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', satnogs_frame_decoder_0_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_file_sink_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '1', satnogs_frame_decoder_0_0, '1']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_file_sink_2, '0']
- [freq_xlating_fir_filter_xxx_0, '0', satellites_doppler_correction_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', satnogs_waterfall_sink_1, '0']
- [iio_pluto_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [low_pass_filter_0_0, '0', analog_quadrature_demod_cf_0_0_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_delay_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0_0, '0']
- [satellites_check_address_0, ok, blocks_message_debug_0, print]
- [satellites_doppler_correction_0, '0', blocks_delay_0, '0']
- [satellites_doppler_correction_0, '0', blocks_file_sink_2_0, '0']
- [satellites_doppler_correction_0, '0', low_pass_filter_0_0, '0']
- [satellites_doppler_correction_0, '0', satnogs_waterfall_sink_1_0, '0']
- [satnogs_frame_decoder_0_0, out, satellites_check_address_0, in]
- [satnogs_frame_decoder_0_0, out, satellites_kiss_server_sink_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
